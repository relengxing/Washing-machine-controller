# Keil uVision project EMF32_DEMO.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: EFM32TG840F32 Silicon Labs
  pack: Keil.EFM32TGxxx_DFP.1.1.0
  cpu: IROM(0x00000000,0x00008000) IRAM(0x20000000,0x00001000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EMF32_DEMO +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: EFM32TG840F32 DEBUG_EFM
  c misc: --c99 --diag_suppress=47
  c include: ..\BSP;..\CMSIS\efm32tg;..\CMSIS\Include;..\EFM32TG_STK3300\config;..\emlib\inc;..\Source;..\App\App_Interface;..\App\App_Head;..\Middle_1278;..\App\App_Gprs;..\App\App_SC;..\App\App_ReadMeter;..\App\App_Report
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ../Source/: main.c sysTick.c
    ../CMSIS/efm32tg/: startup_efm32tg.s
  group CMSIS
    ../CMSIS/efm32tg/: system_efm32tg.c
  group emlib
    ../emlib/src/: em_acmp.c em_adc.c em_assert.c em_cmu.c em_dac.c em_dbg.c em_dma.c em_emu.c em_gpio.c em_i2c.c em_int.c em_lcd.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group bsphead
    ../BSP/: bsp.h bsp_bcp.h Bsp_Led.h Bsp_Uart.h bsp_config.h
  group BSP
    ../BSP/: bsp_acmp.c bsp_adc.c bsp_Dac.c bsp_iic.c bsp_key.c bsp_lcd.c bsp_Led.c bsp_power_ctrl.c bsp_ReedSwitch.c bsp_rtc.c bsp_spi.c bsp_SX127X.c bsp_Test.c bsp_Timer.c bsp_Uart.c bsp_vcmp.c bsp_wdt.c sx1276-Hal.c
  group App_Head
    ../App/App_Head/: App_Head.h App_MemoryConfig.h
    ../App/App_Interface/: App_485_Interface.h
  group App_Interface
    ../App/App_Interface/: App_Gprs_Interface.h App_Para_Interface.h convertDataInterface.h App_Data_interface.h
  group APP_DataFormate
    ../App/APP_DataFormate/: DealWithChar.c DealWithTime.c
  group App_Gprs
    ../App/App_Gprs/: App_M6310.c
  group App_Para&Arg
    ../App/App_Para&Arg/: App_Agr.c App_Para.c App_Agr_Func.c App_Agr_MakeFrame.c
  group App_Data
    ../App/App_Data/: App_Data.c
  group App_ReadMeter
    ../App/App_ReadMeter/: App_485RN.c
  group App_RTC
    ../App/App_RTC/: App_RTC.c
  group readme
    ../readme/: readme.txt
  group App_Rept_Data
    ../App/App_Report/: App_NL.c
